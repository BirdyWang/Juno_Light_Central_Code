# Keil uVision project Juno_Light_Central.uvprojx, settings and files
target nrf52832_xxaa (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: Juno_Light_Central +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_NFCT_PINS_AS_GPIOS BL_SETTINGS_ACCESS_ONLY BOARD_PCA10040 FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\..\..\NRF5_SDK\config;..\..\..\..\..\NRF5_SDK\components;..\..\..\..\..\NRF5_SDK\components\ble\ble_advertising;..\..\..\..\..\NRF5_SDK\components\ble\ble_dtm;..\..\..\..\..\NRF5_SDK\components\ble\ble_link_ctx_manager;..\..\..\..\..\NRF5_SDK\components\ble\ble_racp;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ans_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_bas;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_bas_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_cscs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_cts_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_dfu;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_dis;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_gls;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hids;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hrs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hts;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ias;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ias_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_lbs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_lls;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_nus;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_nus_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_rscs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_tps;..\..\..\..\..\NRF5_SDK\components\ble\common;..\..\..\..\..\NRF5_SDK\components\ble\nrf_ble_gatt;..\..\..\..\..\NRF5_SDK\components\ble\nrf_ble_qwr;..\..\..\..\..\NRF5_SDK\components\ble\peer_manager;..\..\..\..\..\NRF5_SDK\components\drivers_nrf\usbd;..\..\..\..\..\NRF5_SDK\components\drivers_nrf\spi_master;..\..\..\..\..\NRF5_SDK\components\ble\ble_db_discovery;..\..\..\..\..\NRF5_SDK\components\libraries\atomic;..\..\..\..\..\NRF5_SDK\components\libraries\atomic_fifo;..\..\..\..\..\NRF5_SDK\components\libraries\atomic_flags;..\..\..\..\..\NRF5_SDK\components\libraries\balloc;..\..\..\..\..\NRF5_SDK\components\libraries\bootloader;..\..\..\..\..\NRF5_SDK\components\libraries\bootloader\ble_dfu;..\..\..\..\..\NRF5_SDK\components\libraries\bootloader\dfu;..\..\..\..\..\NRF5_SDK\components\libraries\bsp;..\..\..\..\..\NRF5_SDK\components\libraries\button;..\..\..\..\..\NRF5_SDK\components\libraries\cli;..\..\..\..\..\NRF5_SDK\components\libraries\crc16;..\..\..\..\..\NRF5_SDK\components\libraries\delay;..\..\..\..\..\NRF5_SDK\components\libraries\ecc;..\..\..\..\..\NRF5_SDK\components\libraries\experimental_libuarte;..\..\..\..\..\NRF5_SDK\components\libraries\experimental_section_vars;..\..\..\..\..\NRF5_SDK\components\libraries\experimental_task_manager;..\..\..\..\..\NRF5_SDK\components\libraries\fds;..\..\..\..\..\NRF5_SDK\components\libraries\fifo;..\..\..\..\..\NRF5_SDK\components\libraries\fstorage;..\..\..\..\..\NRF5_SDK\components\libraries\gfx;..\..\..\..\..\NRF5_SDK\components\libraries\gpiote;..\..\..\..\..\NRF5_SDK\components\libraries\hardfault;..\..\..\..\..\NRF5_SDK\components\libraries\hci;..\..\..\..\..\NRF5_SDK\components\libraries\led_softblink;..\..\..\..\..\NRF5_SDK\components\libraries\log;..\..\..\..\..\NRF5_SDK\components\libraries\log\src;..\..\..\..\..\NRF5_SDK\components\libraries\low_power_pwm;..\..\..\..\..\NRF5_SDK\components\libraries\mem_manager;..\..\..\..\..\NRF5_SDK\components\libraries\memobj;..\..\..\..\..\NRF5_SDK\components\libraries\mpu;..\..\..\..\..\NRF5_SDK\components\libraries\mutex;..\..\..\..\..\NRF5_SDK\components\libraries\pwm;..\..\..\..\..\NRF5_SDK\components\libraries\pwr_mgmt;..\..\..\..\..\NRF5_SDK\components\libraries\queue;..\..\..\..\..\NRF5_SDK\components\libraries\ringbuf;..\..\..\..\..\NRF5_SDK\components\libraries\scheduler;..\..\..\..\..\NRF5_SDK\components\libraries\sortlist;..\..\..\..\..\NRF5_SDK\components\libraries\spi_mngr;..\..\..\..\..\NRF5_SDK\components\libraries\strerror;..\..\..\..\..\NRF5_SDK\components\libraries\svc;..\..\..\..\..\NRF5_SDK\components\libraries\timer;..\..\..\..\..\NRF5_SDK\components\libraries\twi_mngr;..\..\..\..\..\NRF5_SDK\components\libraries\twi_sensor;..\..\..\..\..\NRF5_SDK\components\libraries\uart;..\..\..\..\..\NRF5_SDK\components\libraries\util;..\..\..\..\..\NRF5_SDK\components\softdevice\common;..\..\..\..\..\NRF5_SDK\components\softdevice\s132\headers;..\..\..\..\..\NRF5_SDK\components\softdevice\s132\headers\nrf52;..\..\..\..\..\NRF5_SDK\components\boards;..\..\..\..\..\NRF5_SDK\external\fprintf;..\..\..\..\..\NRF5_SDK\external\segger_rtt;..\..\..\..\..\NRF5_SDK\integration\nrfx;..\..\..\..\..\NRF5_SDK\integration\nrfx\legacy;..\..\..\..\..\NRF5_SDK\modules\nrfx;..\..\..\..\..\NRF5_SDK\modules\nrfx\drivers\include;..\..\..\..\..\NRF5_SDK\modules\nrfx\hal;..\..\..\..\..\NRF5_SDK\modules\nrfx\mdk;..\..\..\Inc;.\config;..\..\..\..\Juno_Light_Central
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\..\..\NRF5_SDK\config;..\..\..\..\..\NRF5_SDK\components;..\..\..\..\..\NRF5_SDK\components\ble\ble_advertising;..\..\..\..\..\NRF5_SDK\components\ble\ble_dtm;..\..\..\..\..\NRF5_SDK\components\ble\ble_link_ctx_manager;..\..\..\..\..\NRF5_SDK\components\ble\ble_racp;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ans_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_bas;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_bas_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_cscs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_cts_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_dfu;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_dis;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_gls;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hids;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hrs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_hts;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ias;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_ias_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_lbs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_lls;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_nus;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_nus_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_rscs;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\NRF5_SDK\components\ble\ble_services\ble_tps;..\..\..\..\..\NRF5_SDK\components\ble\common;..\..\..\..\..\NRF5_SDK\components\ble\nrf_ble_gatt;..\..\..\..\..\NRF5_SDK\components\ble\nrf_ble_qwr;..\..\..\..\..\NRF5_SDK\components\ble\peer_manager;..\..\..\..\..\NRF5_SDK\components\drivers_nrf\usbd;..\..\..\..\..\NRF5_SDK\components\drivers_nrf\spi_master;..\..\..\..\..\NRF5_SDK\components\ble\ble_db_discovery;..\..\..\..\..\NRF5_SDK\components\libraries\atomic;..\..\..\..\..\NRF5_SDK\components\libraries\atomic_fifo;..\..\..\..\..\NRF5_SDK\components\libraries\atomic_flags;..\..\..\..\..\NRF5_SDK\components\libraries\balloc;..\..\..\..\..\NRF5_SDK\components\libraries\bootloader;..\..\..\..\..\NRF5_SDK\components\libraries\bootloader\ble_dfu;..\..\..\..\..\NRF5_SDK\components\libraries\bootloader\dfu;..\..\..\..\..\NRF5_SDK\components\libraries\bsp;..\..\..\..\..\NRF5_SDK\components\libraries\button;..\..\..\..\..\NRF5_SDK\components\libraries\cli;..\..\..\..\..\NRF5_SDK\components\libraries\crc16;..\..\..\..\..\NRF5_SDK\components\libraries\delay;..\..\..\..\..\NRF5_SDK\components\libraries\ecc;..\..\..\..\..\NRF5_SDK\components\libraries\experimental_libuarte;..\..\..\..\..\NRF5_SDK\components\libraries\experimental_section_vars;..\..\..\..\..\NRF5_SDK\components\libraries\experimental_task_manager;..\..\..\..\..\NRF5_SDK\components\libraries\fds;..\..\..\..\..\NRF5_SDK\components\libraries\fifo;..\..\..\..\..\NRF5_SDK\components\libraries\fstorage;..\..\..\..\..\NRF5_SDK\components\libraries\gfx;..\..\..\..\..\NRF5_SDK\components\libraries\gpiote;..\..\..\..\..\NRF5_SDK\components\libraries\hardfault;..\..\..\..\..\NRF5_SDK\components\libraries\hci;..\..\..\..\..\NRF5_SDK\components\libraries\led_softblink;..\..\..\..\..\NRF5_SDK\components\libraries\log;..\..\..\..\..\NRF5_SDK\components\libraries\log\src;..\..\..\..\..\NRF5_SDK\components\libraries\low_power_pwm;..\..\..\..\..\NRF5_SDK\components\libraries\mem_manager;..\..\..\..\..\NRF5_SDK\components\libraries\memobj;..\..\..\..\..\NRF5_SDK\components\libraries\mpu;..\..\..\..\..\NRF5_SDK\components\libraries\mutex;..\..\..\..\..\NRF5_SDK\components\libraries\pwm;..\..\..\..\..\NRF5_SDK\components\libraries\pwr_mgmt;..\..\..\..\..\NRF5_SDK\components\libraries\queue;..\..\..\..\..\NRF5_SDK\components\libraries\ringbuf;..\..\..\..\..\NRF5_SDK\components\libraries\scheduler;..\..\..\..\..\NRF5_SDK\components\libraries\sortlist;..\..\..\..\..\NRF5_SDK\components\libraries\spi_mngr;..\..\..\..\..\NRF5_SDK\components\libraries\strerror;..\..\..\..\..\NRF5_SDK\components\libraries\svc;..\..\..\..\..\NRF5_SDK\components\libraries\timer;..\..\..\..\..\NRF5_SDK\components\libraries\twi_mngr;..\..\..\..\..\NRF5_SDK\components\libraries\twi_sensor;..\..\..\..\..\NRF5_SDK\components\libraries\uart;..\..\..\..\..\NRF5_SDK\components\libraries\util;..\..\..\..\..\NRF5_SDK\components\softdevice\common;..\..\..\..\..\NRF5_SDK\components\softdevice\s132\headers;..\..\..\..\..\NRF5_SDK\components\softdevice\s132\headers\nrf52;..\..\..\..\..\NRF5_SDK\components\boards;..\..\..\..\..\NRF5_SDK\external\fprintf;..\..\..\..\..\NRF5_SDK\external\segger_rtt;..\..\..\..\..\NRF5_SDK\integration\nrfx;..\..\..\..\..\NRF5_SDK\integration\nrfx\legacy;..\..\..\..\..\NRF5_SDK\modules\nrfx;..\..\..\..\..\NRF5_SDK\modules\nrfx\drivers\include;..\..\..\..\..\NRF5_SDK\modules\nrfx\hal;..\..\..\..\..\NRF5_SDK\modules\nrfx\mdk;..\..\..\..\App_Test_PCB;..\..\..\Inc;.\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x40000
  memory RVCT9: RAM 0x20002a98 size 0x20000
  link misc: --diag_suppress 6330
  group Juno_Application
    ../../../: main.c
    ../../../Src/: Command_Handling.c
  group Juno_Configuration
    ./config/: sdk_config.h
    ../../../: Juno_Light_Central_Config.h Juno_Light_Central_Pin_Map.h
  group Juno_Peripheral_Driver
    ../../../Src/: GPIO.c PWM.c SAADC.c System.c UART.c Juno_BLE.c Juno_Buttonless_DFU.c SPI0_IMU.c SPI1_LED.c
  group Juno_LED_Driver
    ../../../Src/: LED1642GW.c
  group Juno IMU_Sensor
    ../../../Src/: MPU6500_Base_Driver.c MPU6500_DMP_Motion_Driver.c MPU6500.c
  group Board Definition
    C:/Keil_v5/NRF5_SDK/components/boards/: boards.c
  group Board Support
    C:/Keil_v5/NRF5_SDK/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../../../../../NRF5_SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    C:/Keil_v5/NRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    C:/Keil_v5/NRF5_SDK/components/ble/ble_advertising/: ble_advertising.c
    C:/Keil_v5/NRF5_SDK/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    C:/Keil_v5/NRF5_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    C:/Keil_v5/NRF5_SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    C:/Keil_v5/NRF5_SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_DFU
    ../../../../../NRF5_SDK/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    C:/Keil_v5/NRF5_SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../NRF5_SDK/integration/nrfx/legacy/: nrf_drv_spi.c
    ../../../../../NRF5_SDK/modules/nrfx/drivers/src/: nrfx_timer.c nrfx_saadc.c nrfx_spi.c nrfx_pwm.c nrfx_spim.c
    ../../../../../NRF5_SDK/modules/nrfx/soc/: nrfx_atomic.c
    C:/Keil_v5/NRF5_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    C:/Keil_v5/NRF5_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../NRF5_SDK/modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    C:/Keil_v5/NRF5_SDK/components/libraries/button/: app_button.c
    C:/Keil_v5/NRF5_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    C:/Keil_v5/NRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    C:/Keil_v5/NRF5_SDK/components/libraries/timer/: app_timer.c
    C:/Keil_v5/NRF5_SDK/components/libraries/fifo/: app_fifo.c
    ../../../../../NRF5_SDK/components/libraries/pwm/: app_pwm.c
    C:/Keil_v5/NRF5_SDK/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../NRF5_SDK/components/libraries/crc16/: crc16.c
    ../../../../../NRF5_SDK/components/libraries/fds/: fds.c
    C:/Keil_v5/NRF5_SDK/components/libraries/hardfault/: hardfault_implementation.c
    C:/Keil_v5/NRF5_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    C:/Keil_v5/NRF5_SDK/components/libraries/atomic_flags/: nrf_atflags.c
    C:/Keil_v5/NRF5_SDK/components/libraries/atomic/: nrf_atomic.c
    C:/Keil_v5/NRF5_SDK/components/libraries/balloc/: nrf_balloc.c
    C:/Keil_v5/NRF5_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../NRF5_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    C:/Keil_v5/NRF5_SDK/components/libraries/memobj/: nrf_memobj.c
    C:/Keil_v5/NRF5_SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../NRF5_SDK/components/libraries/queue/: nrf_queue.c
    C:/Keil_v5/NRF5_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    C:/Keil_v5/NRF5_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    C:/Keil_v5/NRF5_SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../../../NRF5_SDK/components/libraries/spi_mngr/: nrf_spi_mngr.c
  group nRF_log
    ../../../../../NRF5_SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SVC
    ../../../../../NRF5_SDK/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Segger_RTT
    ../../../../../NRF5_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    C:/Keil_v5/NRF5_SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_6.1.0_softdevice (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x61000
  memory RVCT9: RAM 0x20002a98 size 0x30000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.1.1, CMSIS:CORE 4.3.0, Device:Startup 8.17.0
